/*
 * 空の劇場 - M5Stack StopWatch 側ファーム雛形 (DRAFT / 未検証)
 *
 * 役割:
 *   1. Wi-Fi接続し、program.json と公演ごとの音声(WAV)を取得して LittleFS に保存する
 *   2. RTC(内蔵RX8130CE + NTP補正)でイベント時刻を待ち、振動と音声再生を行う
 *   3. 観察スタンプ数を NVS に保持し、画面に表示する
 *
 * 未検証の箇所 (実機ビルド時に M5Unified / M5StopWatch ライブラリで確認する):
 *   - 振動モーターのAPI (TODO: vibrate())
 *   - WAV再生のAPI詳細 (M5.Speaker.playWav を想定)
 *   - LittleFS のマウントとファイルサイズ上限
 *
 * 設定: PROGRAM_BASE_URL は program.json と audio/<date>/<kind>.wav を
 *       置いたサーバーのURLに書き換える。
 */
#include <M5Unified.h>
#include <WiFi.h>
#include <HTTPClient.h>
#include <ArduinoJson.h>
#include <LittleFS.h>
#include <Preferences.h>
#include <time.h>

static const char* WIFI_SSID = "YOUR_SSID";
static const char* WIFI_PASS = "YOUR_PASS";
static const char* PROGRAM_BASE_URL = "https://kentar0kozai.github.io/sky-theater";

struct Event {
  time_t at;
  String kind;
  String wavPath;
  bool vibrate;
};

static Event g_events[32];
static int g_eventCount = 0;
static int g_nextEvent = 0;
static Preferences g_prefs;

static void vibrate(int ms) {
  // TODO: StopWatch の振動モーターAPIに置き換える
  (void)ms;
}

static bool downloadToFile(const String& url, const String& path) {
  HTTPClient http;
  http.begin(url);
  if (http.GET() != 200) { http.end(); return false; }
  File f = LittleFS.open(path, "w");
  if (!f) { http.end(); return false; }
  http.writeToStream(&f);
  f.close();
  http.end();
  return true;
}

static bool fetchProgram() {
  HTTPClient http;
  http.begin(String(PROGRAM_BASE_URL) + "/program.json");
  if (http.GET() != 200) { http.end(); return false; }
  String body = http.getString();
  http.end();

  JsonDocument doc;
  if (deserializeJson(doc, body)) return false;

  g_eventCount = 0;
  for (JsonObject show : doc["shows"].as<JsonArray>()) {
    if (!show["held"].as<bool>()) continue;
    String date = show["date"].as<String>();
    for (JsonObject ev : show["events"].as<JsonArray>()) {
      if (g_eventCount >= 32) break;
      struct tm tmv = {};
      strptime(ev["time"].as<const char*>(), "%Y-%m-%dT%H:%M:%S", &tmv);
      Event& e = g_events[g_eventCount];
      e.at = mktime(&tmv);
      e.kind = ev["kind"].as<String>();
      e.vibrate = ev["vibrate"].as<bool>();
      e.wavPath = "/" + ev["audio"].as<String>();
      String url = String(PROGRAM_BASE_URL) + "/" + ev["audio"].as<String>();
      if (!LittleFS.exists(e.wavPath)) {
        downloadToFile(url, e.wavPath);
      }
      g_eventCount++;
    }
  }
  // sort by time (simple insertion sort; counts are small)
  for (int i = 1; i < g_eventCount; i++) {
    Event key = g_events[i];
    int j = i - 1;
    while (j >= 0 && g_events[j].at > key.at) { g_events[j + 1] = g_events[j]; j--; }
    g_events[j + 1] = key;
  }
  time_t now = time(nullptr);
  g_nextEvent = 0;
  while (g_nextEvent < g_eventCount && g_events[g_nextEvent].at < now) g_nextEvent++;
  return true;
}

static void playWavFile(const String& path) {
  File f = LittleFS.open(path, "r");
  if (!f) return;
  size_t len = f.size();
  uint8_t* buf = (uint8_t*)ps_malloc(len);
  if (!buf) { f.close(); return; }
  f.read(buf, len);
  f.close();
  // WAV header is 44 bytes for the clips generated by the PC pipeline.
  M5.Speaker.playWav(buf + 44, len - 44);
  free(buf);
}

static void drawScreen() {
  M5.Display.clear();
  M5.Display.setTextSize(2);
  int stamps = g_prefs.getInt("stamps", 0);
  M5.Display.setCursor(60, 90);
  M5.Display.printf("空の劇場");
  M5.Display.setCursor(60, 130);
  M5.Display.printf("スタンプ %d", stamps);
  if (g_nextEvent < g_eventCount) {
    struct tm* lt = localtime(&g_events[g_nextEvent].at);
    M5.Display.setCursor(60, 170);
    M5.Display.printf("次: %02d:%02d %s", lt->tm_hour, lt->tm_min,
                      g_events[g_nextEvent].kind.c_str());
  }
}

void setup() {
  auto cfg = M5.config();
  M5.begin(cfg);
  M5.Display.setRotation(0);
  g_prefs.begin("skytheater", false);
  LittleFS.begin(true);

  WiFi.begin(WIFI_SSID, WIFI_PASS);
  for (int i = 0; i < 40 && WiFi.status() != WL_CONNECTED; i++) delay(500);
  configTzTime("JST-9", "ntp.nict.jp", "pool.ntp.org");
  delay(1500);
  if (WiFi.status() == WL_CONNECTED) fetchProgram();
  drawScreen();
}

void loop() {
  M5.update();
  time_t now = time(nullptr);
  if (g_nextEvent < g_eventCount && now >= g_events[g_nextEvent].at) {
    Event& e = g_events[g_nextEvent];
    if (e.vibrate) vibrate(400);
    playWavFile(e.wavPath);
    if (e.kind == "end") {
      g_prefs.putInt("stamps", g_prefs.getInt("stamps", 0) + 1);
    }
    g_nextEvent++;
    drawScreen();
  }
  delay(200);
}
